VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO INV_X1_SVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.14 BY 0.40 ;
  SYMMETRY X Y ;
END INV_X1_SVT

MACRO INV_X2_LVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.28 BY 0.40 ;
  SYMMETRY X Y ;
END INV_X2_LVT

MACRO NAND2_X1_ULVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.28 BY 0.40 ;
  SYMMETRY X Y ;
END NAND2_X1_ULVT

MACRO NOR2_X1_SVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.28 BY 0.40 ;
  SYMMETRY X Y ;
END NOR2_X1_SVT

MACRO BUF_X1_LVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.14 BY 0.40 ;
  SYMMETRY X Y ;
END BUF_X1_LVT

MACRO BUF_X4_SVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.56 BY 0.40 ;
  SYMMETRY X Y ;
END BUF_X4_SVT

MACRO CKINV_X1_ULVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.14 BY 0.40 ;
  SYMMETRY X Y ;
END CKINV_X1_ULVT

MACRO CKBUF_X2_SVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.28 BY 0.40 ;
  SYMMETRY X Y ;
END CKBUF_X2_SVT

MACRO SDF_X1_SVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.28 BY 0.40 ;
  SYMMETRY X Y ;
END SDF_X1_SVT

MACRO SDF_X2_LVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.56 BY 0.40 ;
  SYMMETRY X Y ;
END SDF_X2_LVT

MACRO ICG_X1_ULVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.28 BY 0.40 ;
  SYMMETRY X Y ;
END ICG_X1_ULVT

MACRO AOI21_X1_SVT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.28 BY 0.40 ;
  SYMMETRY X Y ;
END AOI21_X1_SVT

MACRO SRAM_1024
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 40.00 BY 20.00 ;
  SYMMETRY X Y ;
  OBS
    LAYER M1 ;
      RECT 0.00 0.00 40.00 20.00 ;
    LAYER M2 ;
      RECT 0.00 0.00 10.00 5.00 ;
      RECT 0.00 5.00 10.00 10.00 ;
      RECT 0.00 10.00 10.00 15.00 ;
      RECT 0.00 15.00 10.00 20.00 ;
      RECT 10.00 0.00 20.00 5.00 ;
      RECT 10.00 5.00 20.00 10.00 ;
      RECT 10.00 10.00 20.00 15.00 ;
      RECT 10.00 15.00 20.00 20.00 ;
      RECT 20.00 0.00 30.00 5.00 ;
      RECT 20.00 5.00 30.00 10.00 ;
      RECT 20.00 10.00 30.00 15.00 ;
      RECT 20.00 15.00 30.00 20.00 ;
      RECT 30.00 0.00 40.00 5.00 ;
      RECT 30.00 5.00 40.00 10.00 ;
      RECT 30.00 10.00 40.00 15.00 ;
      RECT 30.00 15.00 40.00 20.00 ;
    LAYER M4 ;
      RECT 0.00 0.00 38.00 19.00 ;
    LAYER M5 ;
      RECT 1.00 1.00 1.40 1.40 ;
      RECT 38.00 18.00 38.40 18.40 ;
  END
END SRAM_1024

MACRO SRAM_512
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 20.00 BY 10.00 ;
  SYMMETRY X Y ;
END SRAM_512

MACRO FILL_8
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 1.12 BY 0.40 ;
  SYMMETRY X Y ;
END FILL_8

MACRO TAP_1
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.14 BY 0.40 ;
  SYMMETRY X Y ;
END TAP_1

MACRO DCAP_4
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.56 BY 0.40 ;
  SYMMETRY X Y ;
END DCAP_4
